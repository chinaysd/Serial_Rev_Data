# Keil uVision project led.uvproj, settings and files
target led (MCS-51)
  device: SC92F8371 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x7F) CLOCK(24000000)
  output: led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user;..\lib;..\bsp;..\TimeOut
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: SC92F837X_C.H
  group bsp
    ../bsp/: bsp_led.c bsp_key.c bsp_uart.c bsp_timer.c
  group Time_Out
    ../TimeOut/: TimeOut.c
